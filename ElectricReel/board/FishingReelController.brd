# Repository freesoulengineers/Fishing

File README.md:

## F학점 공대형 낚시 편

F학점 공대형 낚시 편엔 총 4가지의 장비가 등장합니다.  

1. [스마트 루어](/SmartLure/)
2. [스마트 전동릴](/ElectricReel/)
3. [드론](/DroneRelease/)
4. [어탐 보트](/SmartRCBoat/)

이 중에서 4번 어탐 보트는 방송을 보시고 만들 수 있을거에요. 나머지 3 장비는 못다한 이야기와 디테일이 많기 때문에 이 곳에서 좀 더 자세히 공유합니다. 직접 만들어 보고 싶은 고급 사용자를 위한 자료라 생각해주세요.

### F학점 공대형 낚시편 개발 크레딧
```
- 전동릴 프로그래밍: 송호준
- 스마트루어 프로그래밍: 송호준 / 박동희 / 닥터 심슨
- 회로 설계 및 보드 제작: 송호준
- 하드웨어제작: 송호준
- 3d 프린터 빌려준: 이재경
```

---

### 오픈소스 라이센스
Github의 F학점 공대형 자료들은 소스코드 제외 모든 부분 Creative Commons 저작자표시-동일조건변경허락 (CC BY-SA) 2.0 라이센스를 따릅니다.  

소스코드의 경우에는 GNU General Public License v3.0을 따릅니다.

### 왜 오픈소스?
[공대형 낚시 편 Wiki 가서 확인!](https://github.com/gradefree-eng/Fishing/wiki/F%ED%95%99%EC%A0%90-%EA%B3%B5%EB%8C%80%ED%98%95-%EB%82%9A%EC%8B%9C%ED%8E%B8-%EC%9C%84%ED%82%A4)

### 질문하기
자료 정리와 답변은 F학점 공대형 송호준이 담당하고 있고 방송 기간 동안 지속적으로 응답할것입니다.

질문은 [이 링크](https://github.com/gradefree-eng/Fishing/issues)
에서 초록색 New issue 버튼을 눌러서 작성해주세요.

## EAGLE design ElectricReel/board/FishingReelController.brd

File ElectricReel/README.md:

## 전동 릴 콘트롤러

```
공격적인 물고기 vs 내성적인? 물고기
어떤 줄당기는 패턴이 우리가 잡고자 하는 물고기가 좋아하는 패턴일까?
죽어가는 물고기 패턴일까? 아니면 활기차게 움직이는 물고기 패턴일까?
프로그램을 바꾸면 패턴도 자유롭게 바꿀 수 있으니 우리만의 패턴을 만들어볼까?
```
### 전동릴 콘트롤러 시스템

A 버젼 (은성 매트릭스 300) / B 버젼 (시마노 플레이즈 3000)  

의 두 버젼이 있다.  

**Reel-A**  
은성 매트릭스 300은 버튼 2개로 조정 가능한 릴이라 n-ch mosfet으로
open drain 출력을 만들어 전기적으로 스위치를 눌러주는 식으로 콘트롤 하였고
줄이 얼마나 풀리는지 알기위해서는 릴에서 나오는 자기 인코더의 신호를
마이크로 콘트롤러의 입력핀을 통해 받기 위해 직렬저항을 써서 핀을 보호하였다.

**Reel-B**  
시마노 플레이즈 3000의 경우에는 조금씩 줄을 당기는 버튼이 있는데 이 버튼은 low->high 신호를 줘야해서 서로 (릴과 우리의 마이크로콘트롤러)의 회로를 보호하기 위해 p-ch mosfet의 이용한 open-source 출력으로 회로룰 구성하여 콘트롤 하였고 좀더 부드럽게 줄을 당기는 액션을 하기위해 달려있던 엑셀레이터 레버가 가변저항으로 구현된걸 알고 이를 전기적으로 콘트롤 하기위해 12 bit DAC (MCP4921)를 사용하여 콘트롤 하였다.

시마노 플레이즈 3000에 처음 전원이 인가되었을 때 가변저항값을 체크하는데 이때 저항값이 맞지 않으면 릴이 켜지질 않는데 이를 위해서 기본 저항값을 측정하여 2k + 7.5k의 voltage divider를 구성한 후 가운데 지점에 DAC 출력 핀을 연결하였다. 이와 같은 voltage divider + DAC의 구성인 경우 DAC의 source / sink 전류 출력이 충분하여 우리가 원하는 전압값을 출력해줄 수 있는지 체크하여야한다. MCP4921의 출력 전류는 +/- 25 mA로 우리가 원하는 동작을 수행할 수 있다.

#### 발전 가능한 부분
1. 기판용 케이스를 만들어서 소금기 있는 바닷바람에 대비하자.
2. 커넥터를 핀커넥터를 쓰지말고 원형체결형 커넥터를 쓰자. 아무리 잘만들어도 제일 중요한건 커넥터이다.
3. 시마노릴에서 개조된 엑셀레이터 핸들 가변저항의 값을 adc로 읽어 보자.

#### 파일 살펴보기
- board 폴더: eagle로 디자인한 회로 / 보드 / 거버파일
- code 폴더: trinket pro용 아두이노 코드 2가지 버젼
- BOM 폴더: 보드에 올라가는 부품들 정보
- image 폴더: 각종 참조 사진 들

#### 사용된 기술들
[공대형 낚시 편 Wiki 가서 확인!](https://github.com/gradefree-eng/Fishing/wiki/F%ED%95%99%EC%A0%90-%EA%B3%B5%EB%8C%80%ED%98%95-%EB%82%9A%EC%8B%9C%ED%8E%B8-%EC%9C%84%ED%82%A4)

Parts:
C1, C2: 0.1uF; C0603(1608)
C3: 1uF; C0603(1608)
H1, H2, H3, H4: MOUNT-PAD-ROUND3.2; 3,2-PAD
JP1, JP2, JP3: PINHD-1X6CB; 1X06-CLEANBIG
LOGO1: GRADEFREELOGO-20
Q1: NVF6P02; SOT223
R1, R11, R12: 4.7k; R0603(1608)
R2, R3, R8, R10, R14, R15, R17: 10k; R0603(1608)
R4, R5: R0603(1608)
R6: 7.5k; R0603(1608)
R7: 2k; R0603(1608)
R9, R13, R16: 1k; R0603(1608)
S1, S2, S3: 40-XX; B3F-40XX
SJ1, SJ2: SJ2W; SJ_2
TR1, TR2, TR3: DMN2041L; SOT23
TVS1: SD15C; SOD-323-NOPOL
U1: TRINKETPRO
U2: MCP4921; DIL08
X1, X2: 5268-02; 5628-02

Connections:
+12V: TVS1.2, U1.24 (VBAT), X1.1, X2.1
DAC_CS: U1.2 (D10), U2.2 (#CS)
DAC_MOSI: U1.3 (D11), U2.4 (SDI)
DAC_SCK: U1.5 (D13), U2.3 (SCK)
DGND: C1.2, C2.2, C3.2, JP1.1, JP1.2, JP2.6, JP3.6, R2.1, R5.1, R7.1, R8.1, R10.1, R14.1, R15.1, R17.1, TR1.2 (S), TR2.2 (S), TR3.2 (S), TVS1.1, U1.23 (GND), U1.25 (GND), U1.26 (GND), U2.5 (LDAC), U2.7 (AVSS), X1.2, X2.2
ENC1: R11.1, U1.16 (D3)
ENC1_PULSE: JP3.2, R11.2
ENC2: R12.1, U1.17 (D4)
ENC2_PULSE: JP3.3, R12.2
MODE_A: R9.2, U1.9 (A2)
MODE_B: R13.2, U1.10 (A3)
unnamed: R2.2, SJ1.3, TR1.1 (G)
unnamed: JP1.3, U1.27 (VUSB)
unnamed: JP1.4, U1.28 (RXD)
unnamed: JP1.5, U1.29 (TXD)
unnamed: JP1.6, U1.30 (RST)
unnamed: Q1.1 (G), R3.1, SJ1.1, TR1.3 (D)
unnamed: R1.1, U1.7 (A0)
unnamed: R3.2, SJ2.2
unnamed: R9.1, R10.2, S1.3, S1.4 (P1)
unnamed: R13.1, R14.2, S2.3, S2.4 (P1)
unnamed: R16.1, R17.2, S3.3, S3.4 (P1)
OK_STOP: R16.2, U1.11 (A4)
PICKUP: SJ1.2, U1.1 (D9)
PICKUP_SW: JP2.3, Q1.2 (D), Q1.4 (D)
POTEN_ADC: JP2.5, R1.2
POTEN_DAC: JP2.2, R4.1, R5.2, R6.1, R7.2, U2.8 (DACA)
ROCKREEL_POWER: JP3.1
SHIPREEL_POWER: JP2.1, Q1.3 (S), R4.2, R6.2, SJ2.3
START: R8.2, TR2.1 (G), U1.18 (D5)
START_SW: JP3.4, TR2.3 (D)
STOP: R15.2, TR3.1 (G), U1.19 (D6)
STOP_SW: JP3.5, TR3.3 (D)
VCC: C1.1, C2.1, C3.1, JP2.4, S1.1 (S), S1.2 (S1), S2.1 (S), S2.2 (S1), S3.1 (S), S3.2 (S1), SJ2.1, U1.21 (REG_V), U2.1 (VDD), U2.6 (REFA)

Notes on the sheet:
2k / 7.5k 중요!! 동작 안정을 위한 기본 저항
회로 보호를 위한 직렬 저항
회로 보호를 위한 open-drain 출력
회로 보호를 위한 p-ch open-source 출력
시마노 릴 커넥터 핀
은성 릴 커넥터 핀
시마노 릴
은성 릴
과전압 보호 tvs 다이오드
은성 릴: trinket pro 5V
시마노 릴: trinket pro 3.3V
XTM Grade Free Engineer
Fishing Reel Controller by Hojun Song

Board: 2 copper layers, 72.0 x 80.0 mm, 42 parts (0 on the bottom side), 33 nets.

File ElectricReel/BOM/ElectricReel BOM.xlsx:

Parts | Value | Qty | Package | Manufacturer | Description
JP1, JP2, JP3 |  | 3 | 1X06-CLEANBIG | Any
R4, R5 |  | 2 | R0603(1608) | Any
SJ1, SJ2 |  | 2 | SJ_2 | Any
S1, S2, S3 | B3F-4000 | 3 | B3F-40XX | Omron | A,B,C 모드 스위치
C1, C2 | 0.1uF | 2 | C0603(1608) | Any
R9, R13, R16 | 1k | 3 | R0603(1608) | Any
C3 | 1uF | 1 | C0603(1608) | Any
R7 | 2k | 1 | R0603(1608) | Any | 중요한 저항값- 이게 없으면 시마노릴 안켜짐
R1, R11, R12 | 4.7k | 3 | R0603(1608) | Any | 디지털 핀에서 직렬저항은 회로 보호용
R6 | 7.5k | 1 | R0603(1608) | Any | 중요한 저항값- 이게 없으면 시마노릴 안켜짐
R2, R3, R8, R10, R14, R15, R17 | 10k | 7 | R0603(1608) | Any
X1, X2 | 5268 | 2 | 5628 | Molex
TR1, TR2, TR3 | DMN2041L | 3 | SOT23 | Diodes | open drain 출력을 위한 n-ch Mosfet
LOGO1 | GRADEFREELOGO-20 | 1 | GRADEFREELOGO-20
U2 | MCP4921 | 1 | DIL08 | Microchips | 12 bit DAC (Digital to Analog Converter)
H1, H2, H3, H4 | MOUNT-PAD-ROUND3.2 | 4 | 3,2-PAD | Any
Q1 | NVF6P02 | 1 | SOT223 | Onsemi | p-ch Mosfet
TVS1 | SD15C | 1 | SOD-323-NOPOL | Semtech | 12볼트 과전압 방지 tvs 다이오드
U1 | TRINKETPRO | 1 | TRINKETPRO | Adafruit | 아두이노 기반 마이크로 콘트롤러
시마노 전동 릴 | PLAYS 3000 | 1 |  | 시마노
은성전동 릴 | Matrix 300 | 1 |  | 은성

## EAGLE design SmartLure/board/SmartLURE.brd

File SmartLure/README.md:

## 스마트 루어

```
우리가 잡으려는 물고기는 어떤 빛과 어떤 진동을 좋아할까?
우리가 원하는 대로 빛의 파장과 패턴을 조정하고
진동 주파수를 조정하기 위해 만들어진 프로그램 가능한 루어!
과연??
```

### 스마트 루어 시스템

아두이노 기반인 adafruit사의 trinket 보드와 직접 만든 인터페이스 보드를 이용하여 프로그램 가능한 초소형 루어를 만들었다. 풀컬러 LED + 모터 + 110mAh의 리튬폴리머 배터리가 추가로 장차되었고 완전 방수를 위하여 3d 프린터로 만든 케이스에 실리콘 O ring과 진공 구리스를 사용하여 패킹하였다.

패킹이 완료된 후에는 전류를 소모하지 않게 하기위해 케이스 외부에서 전원을 켤 수 있는 스위치를 생각해야 했는데 MK24시리즈의 reed 스위치를 사용하였다. 자석을 가까이 되면 스위치가 연결되어 전류가 흐르게 되는데 이때 주의할 점은 reed 스위치와 자석의 자기장 방향을 잘 일치시켜주는 것이다.

#### 발전 가능한 부분
1. trinket 보드를 쓰지말고 직접 attiny45를 쓰거나 8 bit PIC 콘트롤러를 쓰면 배터리 크기를 제외하고 새끼 손까락 손톱 크기로 사이즈를 작게 만들 수 있다.
2. 이때도 가장 중요한것은 저전력 모드로 동작하게 프로그래밍하는것.
3. 리드스위치 고장 원인 분석: 자석의 세기가 너무 커서인지 리드스위치의 전류 스펙이 낮아서인지 가끔 리드스위치가 켜진상태로 붙어버리고 원상복귀가 되지 않는경우가 있다. 원인 파악.
4. 진동모터가 움직이는 공간을 충분히 확보하기 위해 스마트 루어 케이스를 여유있게 만들거나 모터를 세로로 배치하자.
5. 스마트 루어의 모양은 두껍기 보다는 작고 날렵한 고기 모양으로 길게 만드는게 물고기에게 더 어필하기 좋다.

#### 파일 살펴보기
- board 폴더: eagle로 디자인한 회로 / 보드 / 거버파일
- code 폴더: trinket 아두이노 코드
- 3d 폴더: 3d 프린터로 인쇄가능한 .stl 파일들
- image 폴더: 각종 참조 사진 들

#### 사용된 기술들
[공대형 낚시 편 Wiki 가서 확인!](https://github.com/gradefree-eng/Fishing/wiki/F%ED%95%99%EC%A0%90-%EA%B3%B5%EB%8C%80%ED%98%95-%EB%82%9A%EC%8B%9C%ED%8E%B8-%EC%9C%84%ED%82%A4)

Parts:
CON1: PINHEADER_1.27
D1: STPS0520Z; SOD-123
JP1, JP2, JP3, JP4, JP5: PINHD-1X1CB; 1X01-CLEANBIG
LED1: LFH1056
LOGO1: GRADEFREELOGO-10
R1, R2, R3, R7: 10k; R0603(1608)
R4: 250R; R0603(1608)
R5, R6: 1k; R0603(1608)
S1: REED-SWITCH-MK-24; MK24
SJ1: SJ2W; SJ_2
TR1, TR2, TR3, TR4: DMN2041L; SOT23
U1: TRINKET

Connections:
B0: SJ1.2, U1.9 (B0)
B1: R2.2, TR2.1 (G), U1.8 (B1)
B2: R3.2, TR3.1 (G), U1.7 (B2)
BLUE: R1.2, SJ1.3, TR1.1 (G)
DGND: JP3.1, R1.1, R2.1, R3.1, R7.1, TR1.2 (S), TR2.2 (S), TR3.2 (S), TR4.2 (S), U1.2 (GND)
MOTOR: R7.2, SJ1.1, TR4.1 (G)
unnamed: LED1.B+, R4.1
unnamed: LED1.G+, R5.1
unnamed: LED1.R+, R6.1
unnamed: LED1.B-, TR1.3 (D)
unnamed: LED1.G-, TR2.3 (D)
unnamed: LED1.R-, TR3.3 (D)
unnamed: JP2.1, S1.2, U1.1 (VBAT)
unnamed: CON1.P$1 (1), D1.C, JP5.1
unnamed: CON1.P$2 (2), D1.A, TR4.3 (D)
VBAT: JP1.1, JP4.1, R4.2, R5.2, R6.2, S1.1

Notes on the sheet:
DMN2041L n-ch MOSFET은 6A 허용전류로 펄스 모터 구동에 적합
초소형 reed 스위치 내장으로 밀봉된 상태에서 전원 콘트롤 가능
XTM Grade Free Engineer
Smart Lure Module by Hojun Song
blue LED는 구동 전압이 커서 저항을 작게

Board: 2 copper layers, 15.2 x 34.3 mm, 23 parts (21 on the bottom side), 16 nets.

File SmartLure/board/Smart Lure BOM.xlsx:

Parts | Value | Qty | Package | Manufacturer | Description
JP1, JP2, JP3, JP4, JP5 |  | 5 | 1X01-CLEANBIG | Any
CON1 |  | 1 | PINHEADER_1.27 | Any
SJ1 |  | 1 | SJ_2 | Any
R5, R6 | 1k | 2 | R0603(1608) | Any
R1, R2, R3, R7 | 10k | 4 | R0603(1608) | Any
R4 | 250R | 1 | R0603(1608) | Any | 파란색의 Vf 동작전압이 높아 저항은 작게
TR1, TR2, TR3, TR4 | DMN2041L | 4 | SOT23 | Diodes | 6A Ids n-ch MOSFET
LOGO1 | GRADEFREELOGO-10 | 1 | GRADEFREELOGO-10
LED1 | LFH1056 | 1 | LFH1056 | Luxpia | 5050 size RGB LED
S1 | MK24-B-2 | 1 | MK24 | Standex-Meder | 300mA 전류 리드 스위치
D1 | STPS0520Z | 1 | SOD-123 | ST | 모터 역전압 방지 쇼트키 다이오드
U1 | TRINKET 3.3V | 1 | TRINKET | Adafruit | 아두이노 기반 마이크로 콘트롤러
Battery | 110mAh 리튬폴리머 | 1 |  | Sparkfun

## Commit log

2016-10-16 :lollipop: Added .gitattributes
2016-10-16 First
2016-10-16 arduino code
2016-10-16 organising
2016-10-16 Create LICENSE
2016-10-16 read me!
2016-10-16 read me
2016-10-16 read me again
2016-10-16 edit
2016-10-16 re upload
2016-10-16 goals
2016-10-16 rc boat
2016-10-16 read res
2016-10-17 sketch image
2016-10-17 whiten
2016-10-17 sketches
2016-10-21 license
2016-10-21 Create LICENSE-GNU
2016-10-26 wiki link
2016-10-26 wiki link name
